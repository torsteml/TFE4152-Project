[aimspice]
[description]
11
Analog part
[end]
